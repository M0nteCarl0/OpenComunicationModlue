# IAR project Open_Comunication_Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ; CMSIS\Device\ST\STM32F4xx\Include\; CMSIS\Include\; STM32F4xx_StdPeriph_Driver\inc\; STM32_USB_OTG_Driver\inc\; STM32_USB_Device_Library\Core\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Open_Comunication_Module.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp
  group Clock
    ./: Clock.c
  group CMSIS
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Flash
    ./: FlashExtended.cpp
  group HAL
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group I2C_Core
    ./: I2C Core.c
  group LED
    ./: LED.c
  group SPI_Core
    ./: SPI_Core.c
  group Startup
    CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group Timer
    ./: Timer.c
  group USART_Core
    ./: USART_Core.cpp
  group USB/DeviceCore
    STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/OCM
    ./: OCM.c usb_bsp.c
  group USB/OTG_FS
    STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB/USB_GPIO
    ./: USB_GPIO.c
  group USB/USB_Stream
    ./: ByteConversion.cpp Comand_protocol.c Comands.cpp USB_Stream.c USB_StreamExample.c
  group WatchDog
    ./: Indep_WD.c
